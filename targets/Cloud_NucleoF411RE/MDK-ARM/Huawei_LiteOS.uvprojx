# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_MBED_TLS,MBEDTLS_CONFIG_FILE=<los_mbedtls_config.h>,LWM2M_LITTLE_ENDIAN,LWM2M_CLIENT_MODE,NDEBUG,LOS_KERNEL_DEBUG_OUT,ATINY_DEBUG,WITH_DTLS
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ..\Inc;..\..\..\osdepends\liteos;..\..\..\kernel\base\include;..\..\..\kernel\include;..\..\..\kernel\extended\include;..\OS_CONFIG;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\arm-m\cortex-m3;..\..\..\drivers\third_party\ST\STM32F4xx_HAL_Driver\Inc;..\..\..\drivers\third_party\ST\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\components\connectivity\lwm2m\core\er-coap-13;..\..\..\components\connectivity\lwm2m\core;..\..\..\drivers\thrid_party\ST\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\components\security\mbedtls\mbedtls_port;..\..\..\components\security\mbedtls\mbedtls-2.6.0\include;..\..\..\components\security\mbedtls\mbedtls-2.6.0\include\mbedtls;..\..\..\include\atiny_lwm2m;..\..\..\include\ota;..\..\..\components\ota\package;..\..\..\components\ota\package\opt;..\..\..\components\ota\utility;..\..\..\components\at;..\..\..\components\shell;..\..\..\components\osport;..\..\..\osdepends;..\..\..\include;..\..\..\components\ota\flag_operate;..\..\..\components\connectivity\lwm2m\examples\shared;..\..\..\components\driver;..\..\..\include\fs;..\..\..\osdepends\liteos\cmsis;..\..\..\osdepends\liteos\cmsis\1.0;..\..\..\osdepends\liteos\cmsis\2.0;..\..\..\components\connectivity\agent_tiny\atiny_lwm2m
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\STM32F411RE-LiteOS.sct
  link misc: --keep *.o(oshell)
  group startup
    ./: los_startup_keil.s
  group user
    ../Src/: main.c sys_init.c usart.c uart_at.c uart_debug.c dwt.c system_stm32f4xx.c
  group devices
    ../../../components/net/at_device/sim5320E/: sim5320E.c
  group liteos/cmsis
    ../../../osdepends/liteos/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group liteos/arch
    ../../../arch/arm/arm-m/armv7-m/keil/: los_dispatch_keil.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group hal_driver
    ../../../drivers/third_party/ST/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c
  group mbedtls
    ../../../components/security/mbedtls/mbedtls-2.6.0/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls_port
    ../../../components/security/mbedtls/mbedtls_port/: dtls_interface.c entropy_hardware_poll.c net_sockets_alt.c timing_alt.c
  group er-coap
    ../../../components/connectivity/lwm2m/core/er-coap-13/: er-coap-13.c
  group lwm2m
    ../../../components/connectivity/lwm2m/core/: block1.c bootstrap.c data.c discover.c json.c liblwm2m.c list.c management.c objects.c observe.c packet.c registration.c tlv.c transaction.c uri.c lwm2m_utils.c
    ../../../components/connectivity/lwm2m/examples/shared/: commandline.c
  group os_adapter
    ../../../osdepends/liteos/: atiny_osdep.c
    ../../../components/net/sal/: atiny_socket.c
  group agent_tiny
    ../../../components/connectivity/agent_tiny/atiny_lwm2m/: agenttiny.c atiny_rpt.c connection.c object_access_control.c object_binary_app_data_container.c object_connectivity_moni.c object_connectivity_stat.c object_device.c object_firmware.c object_location.c object_security.c object_server.c platform_adapter.c util_timer.c
    ../../../components/log/: atiny_log.c
  group agent_demo
    ../appdemo/: agent_tiny_cmd_ioctl.c agent_tiny_demo.c
  group osconfig
    ../OS_CONFIG/: los_builddef.h los_printf.h target_config.h
  group osport
    ../../../components/osport/: iodev.c mem.c mutex.c ring.c sem.c string.c task.c
  group shell
    ../../../components/shell/: shell.h shell_cmd.c shell_main.c shell_test.c
  group at
    ../../../components/at/: at.c at.h
  group driver
    ../../../components/driver/: los_dev.c los_dev_fs.c los_dev_test.c
  group fs
    ../../../components/fs/vfs/: los_vfs.c
  group libc
    ../../../components/lib/libc/: errno.c malloc.c
software components: CMSIS:CORE 5.1.1
