# Keil uVision project IoTClub-EVB-M1.uvprojx, settings and files
target Huawei_LiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Huawei_LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ..\..\..\drivers\third_party\ST\STM32L4xx_HAL_Driver\Inc;..\..\..\drivers\third_party\ST\STM32L4xx_HAL_Driver\Inc\Legacy;..\..\..\kernel\base\include;..\..\..\kernel\include;..\..\..\kernel\extended\include;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\arm-m\cortex-m4;..\..\..\examples\include;..\..\..\components\at;..\..\..\components\osport;..\..\..\components\shell;..\..\..\components\driver;..\..\..\include;..\..\..\include\osdepends\liteos;..\OS_CONFIG;..\DeviceDriver\BC35_95;..\DeviceDriver\BH1750;..\DeviceDriver\DHT11;..\DeviceDriver\GPS;..\DeviceDriver\OLED;..\Apps;..\Hardware;..\Usr;..\..\..\include\fs;..\..\..\osdepends\liteos\cmsis;..\..\..\osdepends\liteos\cmsis\1.0;..\..\..\osdepends\liteos\cmsis\2.0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\IoTClub-EVB-M1.sct
  group STM32L4xx_HAL_Driver
    ../../../drivers/third_party/ST/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c
  group liteos/cmsis
    ../../../osdepends/liteos/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/common/: los_slab.c los_slabmem.c los_memcheck.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
    ../../../kernel/extended/tickless/: los_tickless.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/heap/: los_heap.c los_memory.c
    ../../../components/lib/libc/: malloc.c
  group liteos/arch
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../../arch/arm/arm-m/armv7-m/keil/: los_dispatch.c los_startup.S
  group osconfig
    ../OS_CONFIG/: los_builddef.h los_printf.h target_config.h
  group atframe
    ../../../components/at/: at.c
  group shell
    ../../../components/shell/: shell_cmd.c shell_main.c shell_test.c
  group osport
    ../../../components/osport/: iodev.c mem.c mutex.c ring.c sem.c string.c task.c
  group device_driver
    ../DeviceDriver/BH1750/: BH1750.c
    ../DeviceDriver/DHT11/: DHT11_BUS.c
    ../DeviceDriver/OLED/: OLED.c
    ../DeviceDriver/BC35_95/: NB_DRIVER.c NB_DRIVER.h
    ../DeviceDriver/GPS/: gps.c
  group hardware
    ../Hardware/: adc.c adc.h delay.c delay.h gpio.c gpio.h i2c.c i2c.h uart_at.c uart_debug.c usart.c usart.h stm32l4xx_hal_conf.h uart_sensor.c
  group usr
    ../Usr/: main.c main.h sys_init.c system_stm32l4xx.c sys_init.h
  group apps
    ../Apps/: app_bh1750.c app_csq.c app_dht11.c app_led.c app_main.c app_main.h app_smoke.c app_beep.c
  group driverframe
    ../../../components/driver/: los_dev.c
  group utils
    ../../../utils/: rbtree.c
software components: CMSIS:CORE 5.1.1
