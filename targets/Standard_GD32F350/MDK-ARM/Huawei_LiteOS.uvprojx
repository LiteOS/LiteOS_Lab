# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target Huawei_LiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F350R8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.1.0.0
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LOS_KERNEL_DEBUG_OUT,USE_STDPERIPH_DRIVER,GD32F350
  c misc: --diag_suppress=1,186
  c include: ..\Inc;..\..\..\include\osdepends\liteos;..\..\..\include\osdepends;..\..\..\osdepends\liteos\cmsis;..\..\..\kernel\base\include;..\..\..\kernel\include;..\..\..\kernel\extended\include;..\OS_CONFIG;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\arm-m\cortex-m4;..\Drivers\GD32F3x0_standard_peripheral\Include;..\..\..\arch\arm\common\cmsis;..\..\..\demos\kernel\include;..\..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Huawei_LiteOS.sct
  group startup
    ./: los_startup_keil.s
  group user
    ../Src/: dwt.c main.c sys_init.c usart.c gd32f3x0_eval.c system_gd32f3x0.c
  group liteos/cmsis
    ../../../osdepends/liteos/cmsis/: cmsis_liteos.c
  group liteos/arch
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../../arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
  group Drivers/GD32F3x0_standard_peripheral
    ../Drivers/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group liteos/kernel
    ../../../kernel/: los_init.c
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/extended/tickless/: los_tickless.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
