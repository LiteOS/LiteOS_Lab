# IAR project Huawei_LiteOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F429xx; USE_HAL_DRIVER; MBEDTLS_CONFIG_FILE=<los_mbedtls_config.h>; LWM2M_LITTLE_ENDIAN; LWM2M_CLIENT_MODE; NDEBUG; WITH_DTLS; _DLIB_FILE_DESCRIPTOR; WITH_LWIP; CONFIG_FEATURE_FOTA; LWM2M_WITH_LOGS; ATINY_DEBUG
  ICCARM.CCDiagSuppress: Pa089,Pa134,Pe186,Pa182,Pa084,Pa093
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Core\Include; ..\Inc; ..\..\..\osdepends\liteos\cmsis; ..\..\..\osdepends\liteos\cmsis\1.0; ..\..\..\osdepends\liteos\cmsis\2.0; ..\..\..\kernel\base\include; ..\..\..\kernel\include; ..\OS_CONFIG; ..\..\..\arch\arm\arm-m\include; ..\..\..\arch\arm\arm-m\cortex-m4; ..\..\..\demos; ..\..\..\drivers\third_party\ST\STM32F4xx_HAL_Driver\Inc; ..\..\..\drivers\third_party\ST\STM32F4xx_HAL_Driver\Inc\Legacy; ..\..\..\components\net\lwip\lwip-2.0.3\src\include; ..\..\..\components\net\lwip\lwip_port; ..\..\..\components\net\lwip\lwip_port\OS; ..\..\..\components\connectivity\lwm2m\core\er-coap-13; ..\..\..\components\connectivity\lwm2m\core; ..\..\..\components\connectivity\lwm2m\examples\shared; ..\..\..\components\security\mbedtls\mbedtls_port; ..\..\..\components\security\mbedtls\mbedtls-2.6.0\include; ..\..\..\include; ..\Hardware\Inc; ..\..\..\components\ota\flag_operate; ..\..\..\components\ota\utility; ..\..\..\components\connectivity\agent_tiny\atiny_lwm2m
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Huawei_LiteOS.srec
  ILINK.IlinkOutputFile: Huawei_LiteOS.out
  ILINK.IlinkIcfFile: STM32F429IGTx-LiteOS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group agent_demo
    ../../../demos/agenttiny_lwm2m/: agent_tiny_cmd_ioctl.c agent_tiny_demo.c
    ../../../demos/nbiot_without_atiny/: nb_demo.c sota_demo.c
  group at_framework
    ../../../components/net/at_frame/: at_api.c at_main.c
    ../../../components/net/sal/: atiny_socket.c
  group atiny_tiny
    ../../../components/connectivity/agent_tiny/atiny_lwm2m/: agenttiny.c atiny_fota_manager.c atiny_fota_state.c atiny_rpt.c connection.c firmware_update.c object_access_control.c object_binary_app_data_container.c object_connectivity_moni.c object_device.c object_firmware.c object_location.c object_security.c object_server.c platform_adapter.c util_timer.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../drivers/third_party/ST/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group er-coap
    ../../../components/connectivity/lwm2m/core/er-coap-13/: er-coap-13.c
  group fota
    ../../../components/ota/flag_operate/: flag_manager.c upgrade_flag.c
    ../Lib/: hwpatch_iar.a
    ../../../components/ota/utility/: ota_crc.c
    ../../../components/ota/package/: package.c package_checksum.c package_head.c package_writer.c
  group hardware
    ../Hardware/Src/: hal_flash.c hal_iwdg.c hal_rng.c hal_spi_flash.c
  group liteos/arch
    ../../../arch/arm/arm-m/cortex-m4/iar/: los_dispatch_iar.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group liteos/cmsis
    ../../../osdepends/liteos/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/: los_init.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group log
    ../../../components/log/: atiny_log.c
  group lwip
    ../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c
  group lwip_port
    ../../../components/net/lwip/lwip_port/OS/: ethernetif.c sys_arch.c
  group lwm2m
    ../../../components/connectivity/lwm2m/core/: block1.c bootstrap.c data.c discover.c json.c liblwm2m.c list.c lwm2m_utils.c management.c objects.c observe.c packet.c registration.c tlv.c transaction.c uri.c
    ../../../components/connectivity/lwm2m/examples/shared/: commandline.c
  group mbedtls
    ../../../components/security/mbedtls/mbedtls-2.6.0/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls_port
    ../../../components/security/mbedtls/mbedtls_port/: dtls_interface.c entropy_hardware_poll.c net_sockets_alt.c timing_alt.c
  group nb_iot_api
    ../../../components/connectivity/nb_iot/: los_nb_api.c
  group os_adapter
    ../../../osdepends/liteos/: atiny_osdep.c
  group starup
    ./: los_startup_iar.s
  group user
    ../Src/: at_hal.c dwt.c eth.c flash_adaptor.c main.c ota_port.c sys_init.c system_stm32f4xx.c usart.c user_task.c
  group user_drivers
    ../../../components/net/at_device/nb_bc95/: bc95.c
    ../../../components/net/at_device/wifi_esp8266/: esp8266.c
    ../../../components/net/at_device/gprs_sim900a/: sim900a.c
