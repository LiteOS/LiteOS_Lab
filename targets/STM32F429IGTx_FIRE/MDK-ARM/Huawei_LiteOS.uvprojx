# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx,MBEDTLS_CONFIG_FILE=<los_mbedtls_config.h>,WITH_LWM2M,LWM2M_LITTLE_ENDIAN,LWM2M_CLIENT_MODE,NDEBUG,WITH_DTLS,WITH_AT_FRAMEWORK,LWM2M_WITH_LOGS,CONFIG_FEATURE_FOTA,USE_NB_NEUL95_NO_ATINY,WITH_SOTA
  c misc: --diag_suppress=1,47,177,186,223,1294,1295
  c include: ..\Inc;..\..\..\include\osdepends\liteos;..\OS_CONFIG;..\..\..\drivers\third_party\ST\STM32F4xx_HAL_Driver\Inc;..\..\..\drivers\third_party\ST\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\components\connectivity\lwm2m\core\er-coap-13;..\..\..\components\connectivity\lwm2m\core;..\..\..\components\connectivity\lwm2m\examples\shared;..\..\..\components\connectivity\lwm2m\examples\client;..\..\..\components\security\mbedtls\mbedtls_port;..\..\..\components\security\mbedtls\mbedtls-2.6.0\include;..\..\..\include;..\Hardware\Inc;..\..\..\demos;..\..\..\components\fs\include;..\..\..\components\fs\spiffs\spiffs_git\src;..\..\..\components\fs\spiffs\spiffs_git\src\default;..\..\..\components\fs\fatfs\ff13b\source;..\..\..\components\fs\fatfs\ff13b\source\default;..\..\..\kernel\include;..\..\..\kernel\base\include;..\..\..\kernel\extended\include;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\common\cmsis;..\..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\..\components\net\lwip\lwip_port;..\..\..\components\net\lwip\lwip_port\OS;..\..\..\components\ota\flag_operate;..\..\..\components\ota\utility;..\..\..\tests\cmockery\src\google;..\..\..\components/connectivity/agent_tiny/atiny_lwm2m;..\..\..\osdepends\liteos\cmsis
  asm misc: --diag_suppress=A1581W
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM32F429IGTx-LiteOS.sct
  group user
    ../Src/: system_stm32f4xx.c dwt.c sys_init.c at_hal.c main.c eth.c ota_port.c user_task.c fatfs_hal.c spiffs_hal.c flash_adaptor.c
    ../Lib/: hwpatch.lib
  group at_device
    ../../../components/net/at_device/nb_bc95/: bc95.c
    ../../../components/net/at_device/gprs_sim900a/: sim900a.c
    ../../../components/net/at_device/wifi_esp8266/: esp8266.c
  group liteos/cmsis
    ../../../osdepends/liteos/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
    ../../../kernel/extended/tickless/: los_tickless.c
    ../../../kernel/base/mem/heap/: los_heap.c los_memory.c
  group liteos/arch
    ../Src/: usart.c
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../../arch/arm/arm-m/armv7-m/keil/: los_dispatch.c los_startup.S
  group Drivers/STM32F4xx_HAL_Driver
    ../../../drivers/third_party/ST/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_eth.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_iwdg.c
  group hardware
    ../Hardware/Src/: hal_flash.c hal_iwdg.c hal_rng.c hal_spi_flash.c
  group mbedtls
    ../../../components/security/mbedtls/mbedtls-2.6.0/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls_port
    ../../../components/security/mbedtls/mbedtls_port/: dtls_interface.c entropy_hardware_poll.c net_sockets_alt.c timing_alt.c
  group lwm2m
    ../../../components/connectivity/lwm2m/core/: block1.c bootstrap.c data.c discover.c json.c liblwm2m.c list.c management.c objects.c observe.c packet.c registration.c tlv.c transaction.c uri.c lwm2m_utils.c
    ../../../components/connectivity/lwm2m/examples/shared/: commandline.c
    ../../../components/connectivity/lwm2m/core/er-coap-13/: er-coap-13.c
  group os_depends
    ../../../osdepends/liteos/: atiny_osdep.c
  group atiny_tiny
    ../../../components/connectivity/agent_tiny/atiny_lwm2m/: agenttiny.c atiny_rpt.c connection.c object_access_control.c object_binary_app_data_container.c object_connectivity_moni.c object_connectivity_stat.c object_device.c object_firmware.c object_location.c object_security.c object_server.c platform_adapter.c util_timer.c atiny_fota_manager.c atiny_fota_state.c firmware_update.c
  group atiny_demo
    ../../../demos/agenttiny_lwm2m/: agent_tiny_cmd_ioctl.c agent_tiny_demo.c
    ../../../demos/nbiot_without_atiny/: nb_demo.c sota_demo.c
  group at_framework
    ../../../components/net/at_frame/: at_api.c at_main.c
  group nb_iot_api
    ../../../components/connectivity/nb_iot/: los_nb_api.c
  group ota
    ../../../components/ota/flag_operate/: flag_manager.c upgrade_flag.c
    ../../../components/ota/sota/: sota.c sota_hal.c
    ../../../components/ota/utility/: ota_crc.c
    ../../../components/ota/package/: package.c package_checksum.c package_head.c package_writer.c
  group atiny_dep
    ../../../components/lib/libc/: malloc.c errno.c
    ../../../components/net/sal/: atiny_socket.c
  group vfs
    ../../../components/fs/vfs/: los_vfs.c
  group spiffs
    ../../../components/fs/spiffs/: los_spiffs.c
    ../../../components/fs/spiffs/spiffs_git/src/: spiffs_cache.c spiffs_check.c spiffs_gc.c spiffs_hydrogen.c spiffs_nucleus.c
  group fatfs
    ../../../components/fs/fatfs/: los_fatfs.c
    ../../../components/fs/fatfs/ff13b/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group fs_demo
    ../../../demos/fs/: fatfs_demo.c fs_common.c spiffs_demo.c
  group log
    ../../../components/log/: atiny_log.c
  group lwip
    ../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c
  group lwip_port
    ../../../components/net/lwip/lwip_port/OS/: ethernetif.c sys_arch.c
  group cmockery
    ../../../tests/cmockery/src/: cmockery.c
    ../../../tests/test_suit/: fs_test.c
  group utils
    ../../../utils/: rbtree.c
software components: CMSIS:CORE 5.0.1
